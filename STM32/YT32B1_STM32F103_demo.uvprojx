# Keil uVision project YT32B1_STM32F103_demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YT32B1_STM32F103_demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Basic\delay;.\Basic\sys;.\Hardware\LED;.\Hardware\BUZZER;.\Hardware\KEYPAD4x4;.\Hardware\TM1640;.\Basic\flash;.\Basic\rtc;.\Basic\usart;.\Hardware\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/flash/: flash.c
    ./Basic/rtc/: rtc.c
    ./Basic/usart/: usart.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/BUZZER/: buzzer.c
    ./Hardware/KEYPAD4x4/: KEYPAD4x4.c
    ./Hardware/TM1640/: TM1640.c
    ./Hardware/KEY/: key.c
software components: CMSIS:CORE 5.4.0
